# Repository gnurbs/roomba-ESP12E

File README.md:

# ESP12E WiFi microcontroller for Roombas

track and (remote-) control Roombas

## Hardware
current focus - see [hardware branch](https://github.com/gnurbs/roomba-ESP12E/tree/hardware)
- connects to Roomba's serial Port
- ESP12E module
- buck power converter
- serial header for programming / observing Roomba / ESP12E communication for debugging
- expansion header with unused ESP12E pins 

## ESP12E Software
we're using the [nodemcu Firmware](https://github.com/nodemcu/nodemcu-firmware)
- udp2uart: udp <-> uart proxy. Broken as we need hardware to continue
- server.lua: very limited Rooomba controlling HTTP server that can trigger wakeup, short straight drive and clean
- lib.lua: helper functions one would expect in the std library, added and with functionality as needed

## KiCad design hardware/roomba-esp.kicad_pcb

Parts:
D1: LED; LED-0805
P1: CONN_01X07; mini_DIN_7
P2: CONN_02X10; Socket_Strip_Angled_2x10
P3: CONN_01X04; Socket_Strip_Straight_1x04
R1, R4: 10K; R_0805_HandSoldering
R2: 1K; R_0805_HandSoldering
R3: 5K; R_0805_HandSoldering
U1: ESP-12E
U2: LM2596_module

Connections:
/ADC: P2.19, U1.2 (ADC)
/CS0: P2.12, U1.9 (CS0)
/DD: P1.5, U1.20 (GPIO4)
/GPIO0: P2.5, U1.18 (GPIO0)
/GPIO2: P2.7, U1.17 (GPIO2)
/GPIO5: P2.9, U1.19 (GPIO5)
/GPIO9: P2.11, U1.11 (GPIO9)
/GPIO10: P2.13, U1.12 (GPIO10)
/GPIO12: P2.15, U1.6 (GPIO12)
/GPIO13: P2.17, U1.7 (GPIO13)
/GPIO14: P2.18, U1.5 (GPIO14)
/GPIO15: P2.16, U1.16 (GPIO15)
/GPIO16: D1.2 (A), P2.14, U1.4 (GPIO16)
/MISO: P2.10, U1.10 (MISO)
/MOSI: P2.8, U1.13 (MOSI)
/RESET: P2.20, U1.1 (REST)
/RX: R3.2, R4.1, U1.21 (RXD)
/RX_R: P1.3, P3.3, U1.22 (TXD)
/SCK: P2.6, U1.14 (SCLK)
/TX_R: P1.4, P3.4, R3.1
/VBat: P1.1, P1.2, P2.1, P3.1, U2.4 (VBat)
GND: P1.6, P1.7, P2.2, P2.4, P3.2, R2.2, R4.2, U1.15 (GND), U2.2 (GND), U2.3 (GND)
unnamed: D1.1 (K), R2.1
unnamed: R1.2, U1.3 (CH_PD)
VCC: P2.3, R1.1, U1.8 (VCC), U2.1 (VCC)

Board: 2 copper layers, 33.0 x 40.0 mm, 10 parts (1 on the bottom side), 25 nets.

## Commit log

2015-08-01 initial stuff
2015-08-01 more stuff
2015-08-01 fixed submodules
2015-08-01 wakeup?
2015-08-01 bugfix
2015-08-01 init
2015-08-01 fahren
2015-08-01 clean
2015-08-01 baudrate 115200
2015-08-02 made led working
2015-08-02 set station explicitly
2015-08-02 standalone udp server for the roomba sci interface
2015-08-02 added lcp - convenience wrapper around luatool - have a look inside to see limitations
2015-08-02 removed lua-code not used in this branch
2015-08-03 added kicad-ESP8266 submodule
2015-08-20 initial schematics
2015-09-22 LM2596 buck module
2015-09-22 mini DIN 7 straight connector module
2015-09-22 initial version with unfinished pcb
2015-09-22 kicad gitignore: cache+bak
2015-09-22 removed kicad cruft from git
2015-09-22 finalised rev0 pcb
2015-09-22 fixed some kicad-level path/library setings
2015-09-27 added voltage divider on ESP RX to accomodate for 5V level on 3.3V pin
2015-09-27 gitignored kicad_pcb-bak
2015-09-27 rearrenged roomba connector and voltage divider
2015-09-27 added additional connector to serial in schematic
2015-09-27 added serial header to pcb
2015-09-30 wpa secret now in wpa_secret.lua (gitignore'd)
2015-10-02 added some keepout areas to increases manufacture reliability
2015-10-02 create artwork on pcb
2015-10-02 gerber files for bastli
